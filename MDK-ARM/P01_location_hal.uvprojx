# Keil uVision project P01_location_hal.uvprojx, settings and files
target P01_location_hal (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: P01_location_hal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../application;../common;../interface;../interface/Lora;../driver;../free_rtos/include;../free_rtos/portable;../task;..\interface\Inf_qs100
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c rtc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group application
    ../application/: App_Location.c app_detect_fall.c app_rtos.c
  group common
    ../common/: Com_Debug.c Com_Tools.c cJSON.c Com_Filter.c Com_IMU.c Com_Types.c
  group inerface
    ../interface/: Int_DS3553.c Int_AT6558R.c Int_QS100.c Inf_buzzer.c Inf_mpu6050.c
  group inerface/Lora
    ../interface/Lora/: driver_llcc68.c driver_llcc68_interface.c Int_Lora.c
  group driver
    ../driver/: Driver_I2C2.c
  group free_rtos
    ../free_rtos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../free_rtos/portable/: heap_4.c port.c FreeRTOSConfig.h
  group task
    ../task/: task_buzzer.c task_get_info.c
  group inerface/qs100
    ../interface/Inf_qs100/: Inf_qs100_mqtt.c
software components: CMSIS:CORE 4.3.0
